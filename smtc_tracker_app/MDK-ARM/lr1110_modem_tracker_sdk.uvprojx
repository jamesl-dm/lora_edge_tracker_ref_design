# Keil uVision project lr1110_modem_tracker_sdk.uvprojx, settings and files
target lr1110_modem_tracker_sdk_EU868 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32WB55CGUx STMicroelectronics
  pack: Keil.STM32WBxx_DFP.1.2.0
  cpu: IRAM(0x20000000-0x2003FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4")
  output: lr1110_modem_tracker_sdk +hex
  AfterMake: fromelf #L --bincombined  --output=$L@L.bin
  AfterMake: srecord\srec_cat.exe ../../smtc_tracker_bootloader_ota/MDK-ARM/BLE_Ota/Exe/BLE_Ota.hex -Intel -fill 0xFF 0x08000000 0x08007000 lr1110_modem_tracker_sdk/lr1110_modem_tracker_sdk.hex -Intel -o ../../Hex_merged/lr1110_modem_tracker_EU868.hex -Intel
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32WB55xx,USE_FULL_LL_DRIVER,USE_REGION_EU868,LR1110_TRACKER
  c misc: --diag_suppress 1296
  c include: ../Inc;../../Drivers/STM32WBxx_HAL_Driver/Inc;../../Drivers/STM32WBxx_HAL_Driver/Inc/Legacy;../../Utilities/lpm/tiny_lpm;../../Middlewares/ST/STM32_WPAN;../../Middlewares/ST/STM32_WPAN/interface/patterns/ble_thread;../../Middlewares/ST/STM32_WPAN/interface/patterns/ble_thread/tl;../../Middlewares/ST/STM32_WPAN/interface/patterns/ble_thread/shci;../../Middlewares/ST/STM32_WPAN/utilities;../../Middlewares/ST/STM32_WPAN/ble/core;../../Middlewares/ST/STM32_WPAN/ble/core/auto;../../Middlewares/ST/STM32_WPAN/ble/core/template;../../Middlewares/ST/STM32_WPAN/ble/svc/Inc;../../Middlewares/ST/STM32_WPAN/ble/svc/Src;../../Middlewares/ST/STM32_USB_Device_Library/Core/Inc;../../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Inc;../../Drivers/CMSIS/Device/ST/STM32WBxx/Include;../../Utilities/sequencer;../../Middlewares/ST/STM32_WPAN/ble;../../Drivers/CMSIS/Include;..\..\Drivers\BSP\Components\lis2de12;..\..\Drivers\BSP\Components\Leds;..\..\Drivers\BSP\Components\hall_effect;..\..\Drivers\BSP\Components\external_supply;..\..\Drivers\BSP\Components\rf_switch;..\..\Drivers\BSP\Components\usr_button;..\Inc\smtc_hal;..\Inc\boards;..\Src\radio\lr1110_modem\src;..\Src\radio\gnss;..\Src\radio\wifi;..\Src\radio;..\Src\apps\update-firmware;..\Src\apps\Tracker;..\Inc\ble\app;..\Src\radio\lorawan_config
  library: MicroLIB
  memory RVCT4: ROM 0x8007000 size 0x79000
  memory RVCT9: RAM 0x20000004 size 0x2fc00
  scatter file: stm32wb55xx_flash_cm4.sct
  link misc: --keep *.o(TAG_OTA_START)
--keep *.o(TAG_OTA_END)
  group Application/MDK-ARM
    ./: startup_stm32wb55xx_cm4.s
  group Application/User
    ../Src/apps/Tracker/: main_tracker.c main_read_internal_log.c
    ../Src/apps/LoRaWAN/: main_lorawan.c
    ../Src/apps/gnss_test/: main_test_gnss.c
    ../Src/apps/wifi_test/: main_test_wifi.c
    ../Src/apps/tx_continuous_test/: main_test_tx_continuous.c
    ../Src/apps/low-power/: main_low_power.c
    ../Src/apps/update-firmware/: update_firmware.c
    ../Src/apps/ble_standalone/: main_BLE_standalone.c
    ../Src/: app_entry.c app_debug.c hw_timerserver.c stm32_lpm_if.c stm32wbxx_it.c
  group Application/User/STM32_WPAN/App
    ../Src/ble/app/: app_ble.c p2p_server_app.c ble_thread.c
  group Application/User/STM32_WPAN/Target
    ../Src/ble/target/: hw_ipcc.c
  group Drivers/STM32WBxx_HAL_Driver
    ../../Drivers/STM32WBxx_HAL_Driver/Src/: stm32wbxx_hal_gpio.c stm32wbxx_hal_rcc.c stm32wbxx_hal_rcc_ex.c stm32wbxx_hal_flash.c stm32wbxx_hal_flash_ex.c stm32wbxx_hal_hsem.c stm32wbxx_hal_dma.c stm32wbxx_hal_dma_ex.c stm32wbxx_hal_pwr.c stm32wbxx_hal_pwr_ex.c stm32wbxx_hal_cortex.c stm32wbxx_hal.c stm32wbxx_hal_exti.c stm32wbxx_hal_i2c.c stm32wbxx_hal_i2c_ex.c stm32wbxx_hal_adc.c stm32wbxx_hal_adc_ex.c stm32wbxx_ll_adc.c stm32wbxx_hal_rtc.c stm32wbxx_hal_rtc_ex.c stm32wbxx_hal_spi.c stm32wbxx_hal_spi_ex.c stm32wbxx_hal_tim.c stm32wbxx_hal_tim_ex.c stm32wbxx_hal_uart.c stm32wbxx_hal_uart_ex.c stm32wbxx_ll_rtc.c stm32wbxx_ll_spi.c stm32wbxx_hal_lptim.c stm32wbxx_hal_rng.c
  group Drivers/CMSIS
    ../Src/: system_stm32wbxx.c
  group Middlewares/STM32_WPAN
    ../../Middlewares/ST/STM32_WPAN/interface/patterns/ble_thread/tl/: tl_mbox.c hci_tl.c hci_tl_if.c shci_tl.c shci_tl_if.c
    ../../Middlewares/ST/STM32_WPAN/interface/patterns/ble_thread/shci/: shci.c
    ../../Middlewares/ST/STM32_WPAN/utilities/: dbg_trace.c otp.c stm_list.c stm_queue.c
    ../../Middlewares/ST/STM32_WPAN/ble/core/template/: osal.c
    ../../Middlewares/ST/STM32_WPAN/ble/svc/Src/: svc_ctl.c p2p_stm.c
    ../../Middlewares/ST/STM32_WPAN/ble/core/auto/: ble_gap_aci.c ble_gatt_aci.c ble_hal_aci.c ble_hci_le.c ble_l2cap_aci.c
  group Utilities
    ../../Utilities/lpm/tiny_lpm/: stm32_lpm.c
    ../../Utilities/sequencer/: stm32_seq.c
  group Drivers/BSP/Components
    ../../Drivers/BSP/Components/lis2de12/: lis2de12.c
    ../../Drivers/BSP/Components/hall_effect/: hall_effect.c
    ../../Drivers/BSP/Components/Leds/: leds.c
    ../../Drivers/BSP/Components/external_supply/: external_supply.c
    ../../Drivers/BSP/Components/rf_switch/: pe4259.c
    ../../Drivers/BSP/Components/usr_button/: usr_button.c
  group tracker_utility
    ../Src/apps/Tracker/: tracker_utility.c
  group Wi-Fi Scan
    ../Src/radio/wifi/: wifi_scan.c
  group GNSS Scan
    ../Src/radio/gnss/: gnss_scan.c
  group LoRaWAN Config
    ../Src/radio/lorawan_config/: lorawan_config.c
  group lr1110 modem drivers
    ../Src/radio/: lr1110.c lr1110_modem_hal.c
    ../Src/radio/lr1110_modem/src/: lr1110_bootloader.c lr1110_modem_gnss.c lr1110_modem_lorawan.c lr1110_modem_system.c lr1110_modem_wifi.c
  group board
    ../Src/boards/: lr1110_tracker_board.c utilities.c
  group smtc_hal
    ../Src/smtc_hal/: smtc_hal_flash.c smtc_hal_gpio.c smtc_hal_i2c.c smtc_hal_mcu.c smtc_hal_rng.c smtc_hal_rtc.c smtc_hal_spi.c smtc_hal_tmr_list.c smtc_hal_tmr.c smtc_hal_uart.c smtc_hal_watchdog.c smtc_hal_adc.c
target lr1110_modem_tracker_sdk_US915 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32WB55CGUx STMicroelectronics
  pack: Keil.STM32WBxx_DFP.1.2.0
  cpu: as above
  output: lr1110_modem_tracker_sdk +hex
  AfterMake: fromelf #L --bincombined  --output=$L@L.bin
  AfterMake: srecord\srec_cat.exe ../../smtc_tracker_bootloader_ota/MDK-ARM/BLE_Ota/Exe/BLE_Ota.hex -Intel -fill 0xFF 0x08000000 0x08007000 lr1110_modem_tracker_sdk/lr1110_modem_tracker_sdk.hex -Intel -o ../../Hex_merged/lr1110_modem_tracker_US915.hex -Intel
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32WB55xx,USE_FULL_LL_DRIVER,USE_REGION_US915,LR1110_TRACKER
  c misc: --diag_suppress 1296
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8007000 size 0x79000
  memory RVCT9: RAM 0x20000004 size 0x2fc00
  scatter file: stm32wb55xx_flash_cm4.sct
  link misc: --keep *.o(TAG_OTA_START)
--keep *.o(TAG_OTA_END)
target lr1110_modem_tracker_update_lr1110_trx_to_modem (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32WB55CGUx STMicroelectronics
  pack: Keil.STM32WBxx_DFP.1.2.0
  cpu: as above
  output: lr1110_modem_tracker_sdk +hex
  AfterMake: fromelf #L --bincombined  --output=$L@L.bin
  AfterMake: srecord\srec_cat.exe ../../smtc_tracker_bootloader_ota/MDK-ARM/BLE_Ota/Exe/BLE_Ota.hex -Intel -fill 0xFF 0x08000000 0x08007000 lr1110_modem_tracker_sdk/lr1110_modem_tracker_sdk.hex -Intel -o ../../Hex_merged/lr1110_modem_tracker_update_trx_to_modem.hex -Intel
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32WB55xx,USE_FULL_LL_DRIVER,USE_REGION_EU868,LR1110_TRACKER,TRX_TO_MODEM
  c misc: --diag_suppress 1296
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8007000 size 0x79000
  memory RVCT9: RAM 0x20000004 size 0x2fc00
  scatter file: stm32wb55xx_flash_cm4.sct
  link misc: --keep *.o(TAG_OTA_START)
--keep *.o(TAG_OTA_END)
target lr1110_modem_tracker_update_lr1110_modem_to_modem (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32WB55CGUx STMicroelectronics
  pack: Keil.STM32WBxx_DFP.1.2.0
  cpu: as above
  output: lr1110_modem_tracker_sdk +hex
  AfterMake: fromelf #L --bincombined  --output=$L@L.bin
  AfterMake: srecord\srec_cat.exe ../../smtc_tracker_bootloader_ota/MDK-ARM/BLE_Ota/Exe/BLE_Ota.hex -Intel -fill 0xFF 0x08000000 0x08007000 lr1110_modem_tracker_sdk/lr1110_modem_tracker_sdk.hex -Intel -o ../../Hex_merged/lr1110_modem_tracker_update_modem_to_modem.hex -Intel
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32WB55xx,USE_FULL_LL_DRIVER,USE_REGION_EU868,LR1110_TRACKER,MODEM_TO_MODEM
  c misc: --diag_suppress 1296
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8007000 size 0x79000
  memory RVCT9: RAM 0x20000004 size 0x2fc00
  scatter file: stm32wb55xx_flash_cm4.sct
  link misc: --keep *.o(TAG_OTA_START)
--keep *.o(TAG_OTA_END)
target lr1110_modem_tracker_update_lr1110_modem_to_trx (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32WB55CGUx STMicroelectronics
  pack: Keil.STM32WBxx_DFP.1.2.0
  cpu: as above
  output: lr1110_modem_tracker_sdk +hex
  AfterMake: fromelf #L --bincombined  --output=$L@L.bin
  AfterMake: srecord\srec_cat.exe ../../smtc_tracker_bootloader_ota/MDK-ARM/BLE_Ota/Exe/BLE_Ota.hex -Intel -fill 0xFF 0x08000000 0x08007000 lr1110_modem_tracker_sdk/lr1110_modem_tracker_sdk.hex -Intel -o ../../Hex_merged/lr1110_modem_tracker_update_modem_to_trx.hex -Intel
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32WB55xx,USE_FULL_LL_DRIVER,USE_REGION_EU868,LR1110_TRACKER,MODEM_TO_TRX
  c misc: --diag_suppress 1296
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8007000 size 0x79000
  memory RVCT9: RAM 0x20000004 size 0x2fc00
  scatter file: stm32wb55xx_flash_cm4.sct
  link misc: --keep *.o(TAG_OTA_START)
--keep *.o(TAG_OTA_END)
target lr1110_modem_lorawan_EU868 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32WB55CGUx STMicroelectronics
  pack: Keil.STM32WBxx_DFP.1.2.0
  cpu: as above
  output: lr1110_modem_tracker_sdk +hex
  AfterMake: fromelf #L --bincombined  --output=$L@L.bin
  AfterMake: srecord\srec_cat.exe ../../smtc_tracker_bootloader_ota/MDK-ARM/BLE_Ota/Exe/BLE_Ota.hex -Intel -fill 0xFF 0x08000000 0x08007000 lr1110_modem_tracker_sdk/lr1110_modem_tracker_sdk.hex -Intel -o ../../Hex_merged/lr1110_modem_lorawan_EU868.hex -Intel
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: as above
  c misc: --diag_suppress 1296
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8007000 size 0x79000
  memory RVCT9: RAM 0x20000004 size 0x2fc00
  scatter file: stm32wb55xx_flash_cm4.sct
  link misc: --keep *.o(TAG_OTA_START)
--keep *.o(TAG_OTA_END)
target lr1110_modem_lorawan_US915 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32WB55CGUx STMicroelectronics
  pack: Keil.STM32WBxx_DFP.1.2.0
  cpu: as above
  output: lr1110_modem_tracker_sdk +hex
  AfterMake: fromelf #L --bincombined  --output=$L@L.bin
  AfterMake: srecord\srec_cat.exe ../../smtc_tracker_bootloader_ota/MDK-ARM/BLE_Ota/Exe/BLE_Ota.hex -Intel -fill 0xFF 0x08000000 0x08007000 lr1110_modem_tracker_sdk/lr1110_modem_tracker_sdk.hex -Intel -o ../../Hex_merged/lr1110_modem_lorawan_US915.hex -Intel
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: as above
  c misc: --diag_suppress 1296
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8007000 size 0x79000
  memory RVCT9: RAM 0x20000004 size 0x2fc00
  scatter file: stm32wb55xx_flash_cm4.sct
  link misc: --keep *.o(TAG_OTA_START)
--keep *.o(TAG_OTA_END)
target lr1110_modem_test_gnss (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32WB55CGUx STMicroelectronics
  pack: Keil.STM32WBxx_DFP.1.2.0
  cpu: as above
  output: lr1110_modem_tracker_sdk +hex
  AfterMake: fromelf #L --bincombined  --output=$L@L.bin
  AfterMake: srecord\srec_cat.exe ../../smtc_tracker_bootloader_ota/MDK-ARM/BLE_Ota/Exe/BLE_Ota.hex -Intel -fill 0xFF 0x08000000 0x08007000 lr1110_modem_tracker_sdk/lr1110_modem_tracker_sdk.hex -Intel -o ../../Hex_merged/lr1110_modem_loramac_EU868.hex -Intel
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: as above
  c misc: --diag_suppress 1296
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8007000 size 0x79000
  memory RVCT9: RAM 0x20000004 size 0x2fc00
  scatter file: stm32wb55xx_flash_cm4.sct
  link misc: --keep *.o(TAG_OTA_START)
--keep *.o(TAG_OTA_END)
target lr1110_modem_test_wifi (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32WB55CGUx STMicroelectronics
  pack: Keil.STM32WBxx_DFP.1.2.0
  cpu: as above
  output: lr1110_modem_tracker_sdk +hex
  AfterMake: fromelf #L --bincombined  --output=$L@L.bin
  AfterMake: as above
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: as above
  c misc: --diag_suppress 1296
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8007000 size 0x79000
  memory RVCT9: RAM 0x20000004 size 0x2fc00
  scatter file: stm32wb55xx_flash_cm4.sct
  link misc: --keep *.o(TAG_OTA_START)
--keep *.o(TAG_OTA_END)
target lr1110_modem_test_tx_continuous (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32WB55CGUx STMicroelectronics
  pack: Keil.STM32WBxx_DFP.1.2.0
  cpu: as above
  output: lr1110_modem_tracker_sdk +hex
  AfterMake: fromelf #L --bincombined  --output=$L@L.bin
  AfterMake: srecord\srec_cat.exe ../../smtc_tracker_bootloader_ota/MDK-ARM/BLE_Ota/Exe/BLE_Ota.hex -Intel -fill 0xFF 0x08000000 0x08007000 lr1110_modem_tracker_sdk/lr1110_modem_tracker_sdk.hex -Intel -o ../../Hex_merged/lr1110_modem_tracker_tx_continuous.hex -Intel
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: as above
  c misc: --diag_suppress 1296
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8007000 size 0x79000
  memory RVCT9: RAM 0x20000004 size 0x2fc00
  scatter file: stm32wb55xx_flash_cm4.sct
  link misc: --keep *.o(TAG_OTA_START)
--keep *.o(TAG_OTA_END)
target lr1110_modem_test_low_power (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32WB55CGUx STMicroelectronics
  pack: Keil.STM32WBxx_DFP.1.2.0
  cpu: as above
  output: lr1110_modem_tracker_sdk +hex
  AfterMake: fromelf #L --bincombined  --output=$L@L.bin
  AfterMake: as above
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: as above
  c misc: --diag_suppress 1296
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8007000 size 0x79000
  memory RVCT9: RAM 0x20000004 size 0x2fc00
  scatter file: stm32wb55xx_flash_cm4.sct
  link misc: --keep *.o(TAG_OTA_START)
--keep *.o(TAG_OTA_END)
target lr1110_modem_read_internal_log (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32WB55CGUx STMicroelectronics
  pack: Keil.STM32WBxx_DFP.1.2.0
  cpu: as above
  output: lr1110_modem_tracker_sdk +hex
  AfterMake: fromelf #L --bincombined  --output=$L@L.bin
  AfterMake: as above
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: as above
  c misc: --diag_suppress 1296
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8007000 size 0x79000
  memory RVCT9: RAM 0x20000004 size 0x2fc00
  scatter file: stm32wb55xx_flash_cm4.sct
  link misc: --keep *.o(TAG_OTA_START)
--keep *.o(TAG_OTA_END)
software components: CMSIS:CORE 4.3.0
